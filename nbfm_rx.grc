options:
  parameters:
    author: Admin
    generate_options: qt_gui
    id: nbfm_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Gain_rf
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '48'
    value: '30'
  states: {}
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    start: 3e3
    step: 10e3
    stop: 250e3
    value: 3e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 446e6
    step: '1000'
    stop: 447e6
    value: 446e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 2.5e3
    quad_rate: '96000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '20'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,2e6,5e3,2e3)
    type: ccc
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '24'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '10'
    freq0: freq
    gain0: Gain_rf
    gain_mode0: 'False'
    if_gain0: '10'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', audio_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_nbfm_rx_0, '0']
- [rtlsdr_source_0, '0', fosphor_qt_sink_c_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
